# Keil uVision project balance_bike.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: balance_bike +hex
  c flags: Optim=1
  c include: .\lib\inc;.\interrupt;.\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group boot
    ./boot/: cortexm3_macro.s stm32f10x_vector.s
  group interrupt
    ./interrupt/: stm32f10x_it.c
  group lib
    ./lib/src/: stm32f10x_flash.c stm32f10x_lib.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_nvic.c stm32f10x_usart.c stm32f10x_systick.c stm32f10x_tim.c
  group main
    ./main/: main.c
  group i2c
    ./i2c/: i2c.c
  group gy521
    ./gy521/: gy521.c
  group uart
    ./uart/: uart.c
  group disp
    ./disp/: disp.c
  group motor
    ./motor/: motor.c
  group angle
    ./angle/: angle.c
